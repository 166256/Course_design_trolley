# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_LD
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\adc;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\PWM;..\USER;..\HARDWARE\EXTRA;..\HARDWARE\flash;..\HARDWARE\DataScope_DP;..\HARDWARE\exti;..\HARDWARE\TIMER;..\HARDWARE\ENCODER;..\HARDWARE\CONTROL;..\HARDWARE\spi;..\HARDWARE\BUZZER;..\HARDWARE\Tim_pwm;..\HARDWARE\Encoder_speed;..\HARDWARE\GPIO
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group HARWARD
    ../HARDWARE/LED/: led.c
    ../HARDWARE/spi/: spi.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/Encoder_speed/: Tim_encoder_speed.c
    ../HARDWARE/Tim_pwm/: Tim_pwm.c
    ../HARDWARE/GPIO/: gpio.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s core_cm3.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
